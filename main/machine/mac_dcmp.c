// mac_dcmp.c - compressed Macintosh resources: C11 migration of dsp-cpp's
// machine/mac_dcmp.cpp (see mac_dcmp.h).
#include "mac_dcmp.h"

#include <stdbool.h>
#include <stdlib.h>
#include <string.h>

static const uint8_t kDcmp0Table[] = {
    0x00, 0x00, 0x4e, 0xba, 0x00, 0x08, 0x4e, 0x75, 0x00, 0x0c, 0x4e, 0xad, 0x20, 0x53, 0x2f, 0x0b,
    0x61, 0x00, 0x00, 0x10, 0x70, 0x00, 0x2f, 0x00, 0x48, 0x6e, 0x20, 0x50, 0x20, 0x6e, 0x2f, 0x2e,
    0xff, 0xfc, 0x48, 0xe7, 0x3f, 0x3c, 0x00, 0x04, 0xff, 0xf8, 0x2f, 0x0c, 0x20, 0x06, 0x4e, 0xed,
    0x4e, 0x56, 0x20, 0x68, 0x4e, 0x5e, 0x00, 0x01, 0x58, 0x8f, 0x4f, 0xef, 0x00, 0x02, 0x00, 0x18,
    0x60, 0x00, 0xff, 0xff, 0x50, 0x8f, 0x4e, 0x90, 0x00, 0x06, 0x26, 0x6e, 0x00, 0x14, 0xff, 0xf4,
    0x4c, 0xee, 0x00, 0x0a, 0x00, 0x0e, 0x41, 0xee, 0x4c, 0xdf, 0x48, 0xc0, 0xff, 0xf0, 0x2d, 0x40,
    0x00, 0x12, 0x30, 0x2e, 0x70, 0x01, 0x2f, 0x28, 0x20, 0x54, 0x67, 0x00, 0x00, 0x20, 0x00, 0x1c,
    0x20, 0x5f, 0x18, 0x00, 0x26, 0x6f, 0x48, 0x78, 0x00, 0x16, 0x41, 0xfa, 0x30, 0x3c, 0x28, 0x40,
    0x72, 0x00, 0x28, 0x6e, 0x20, 0x0c, 0x66, 0x00, 0x20, 0x6b, 0x2f, 0x07, 0x55, 0x8f, 0x00, 0x28,
    0xff, 0xfe, 0xff, 0xec, 0x22, 0xd8, 0x20, 0x0b, 0x00, 0x0f, 0x59, 0x8f, 0x2f, 0x3c, 0xff, 0x00,
    0x01, 0x18, 0x81, 0xe1, 0x4a, 0x00, 0x4e, 0xb0, 0xff, 0xe8, 0x48, 0xc7, 0x00, 0x03, 0x00, 0x22,
    0x00, 0x07, 0x00, 0x1a, 0x67, 0x06, 0x67, 0x08, 0x4e, 0xf9, 0x00, 0x24, 0x20, 0x78, 0x08, 0x00,
    0x66, 0x04, 0x00, 0x2a, 0x4e, 0xd0, 0x30, 0x28, 0x26, 0x5f, 0x67, 0x04, 0x00, 0x30, 0x43, 0xee,
    0x3f, 0x00, 0x20, 0x1f, 0x00, 0x1e, 0xff, 0xf6, 0x20, 0x2e, 0x42, 0xa7, 0x20, 0x07, 0xff, 0xfa,
    0x60, 0x02, 0x3d, 0x40, 0x0c, 0x40, 0x66, 0x06, 0x00, 0x26, 0x2d, 0x48, 0x2f, 0x01, 0x70, 0xff,
    0x60, 0x04, 0x18, 0x80, 0x4a, 0x40, 0x00, 0x40, 0x00, 0x2c, 0x2f, 0x08, 0x00, 0x11, 0xff, 0xe4,
    0x21, 0x40, 0x26, 0x40, 0xff, 0xf2, 0x42, 0x6e, 0x4e, 0xb9, 0x3d, 0x7c, 0x00, 0x38, 0x00, 0x0d,
    0x60, 0x06, 0x42, 0x2e, 0x20, 0x3c, 0x67, 0x0c, 0x2d, 0x68, 0x66, 0x08, 0x4a, 0x2e, 0x4a, 0xae,
    0x00, 0x2e, 0x48, 0x40, 0x22, 0x5f, 0x22, 0x00, 0x67, 0x0a, 0x30, 0x07, 0x42, 0x67, 0x00, 0x32,
    0x20, 0x28, 0x00, 0x09, 0x48, 0x7a, 0x02, 0x00, 0x2f, 0x2b, 0x00, 0x05, 0x22, 0x6e, 0x66, 0x02,
    0xe5, 0x80, 0x67, 0x0e, 0x66, 0x0a, 0x00, 0x50, 0x3e, 0x00, 0x66, 0x0c, 0x2e, 0x00, 0xff, 0xee,
    0x20, 0x6d, 0x20, 0x40, 0xff, 0xe0, 0x53, 0x40, 0x60, 0x08, 0x04, 0x80, 0x00, 0x68, 0x0b, 0x7c,
    0x44, 0x00, 0x41, 0xe8, 0x48, 0x41,
};

static const uint8_t kDcmp2Table[] = {
    0x00, 0x00, 0x00, 0x08, 0x4e, 0xba, 0x20, 0x6e, 0x4e, 0x75, 0x00, 0x0c, 0x00, 0x04, 0x70, 0x00,
    0x00, 0x10, 0x00, 0x02, 0x48, 0x6e, 0xff, 0xfc, 0x60, 0x00, 0x00, 0x01, 0x48, 0xe7, 0x2f, 0x2e,
    0x4e, 0x56, 0x00, 0x06, 0x4e, 0x5e, 0x2f, 0x00, 0x61, 0x00, 0xff, 0xf8, 0x2f, 0x0b, 0xff, 0xff,
    0x00, 0x14, 0x00, 0x0a, 0x00, 0x18, 0x20, 0x5f, 0x00, 0x0e, 0x20, 0x50, 0x3f, 0x3c, 0xff, 0xf4,
    0x4c, 0xee, 0x30, 0x2e, 0x67, 0x00, 0x4c, 0xdf, 0x26, 0x6e, 0x00, 0x12, 0x00, 0x1c, 0x42, 0x67,
    0xff, 0xf0, 0x30, 0x3c, 0x2f, 0x0c, 0x00, 0x03, 0x4e, 0xd0, 0x00, 0x20, 0x70, 0x01, 0x00, 0x16,
    0x2d, 0x40, 0x48, 0xc0, 0x20, 0x78, 0x72, 0x00, 0x58, 0x8f, 0x66, 0x00, 0x4f, 0xef, 0x42, 0xa7,
    0x67, 0x06, 0xff, 0xfa, 0x55, 0x8f, 0x28, 0x6e, 0x3f, 0x00, 0xff, 0xfe, 0x2f, 0x3c, 0x67, 0x04,
    0x59, 0x8f, 0x20, 0x6b, 0x00, 0x24, 0x20, 0x1f, 0x41, 0xfa, 0x81, 0xe1, 0x66, 0x04, 0x67, 0x08,
    0x00, 0x1a, 0x4e, 0xb9, 0x50, 0x8f, 0x20, 0x2e, 0x00, 0x07, 0x4e, 0xb0, 0xff, 0xf2, 0x3d, 0x40,
    0x00, 0x1e, 0x20, 0x68, 0x66, 0x06, 0xff, 0xf6, 0x4e, 0xf9, 0x08, 0x00, 0x0c, 0x40, 0x3d, 0x7c,
    0xff, 0xec, 0x00, 0x05, 0x20, 0x3c, 0xff, 0xe8, 0xde, 0xfc, 0x4a, 0x2e, 0x00, 0x30, 0x00, 0x28,
    0x2f, 0x08, 0x20, 0x0b, 0x60, 0x02, 0x42, 0x6e, 0x2d, 0x48, 0x20, 0x53, 0x20, 0x40, 0x18, 0x00,
    0x60, 0x04, 0x41, 0xee, 0x2f, 0x28, 0x2f, 0x01, 0x67, 0x0a, 0x48, 0x40, 0x20, 0x07, 0x66, 0x08,
    0x01, 0x18, 0x2f, 0x07, 0x30, 0x28, 0x3f, 0x2e, 0x30, 0x2b, 0x22, 0x6e, 0x2f, 0x2b, 0x00, 0x2c,
    0x67, 0x0c, 0x22, 0x5f, 0x60, 0x06, 0x00, 0xff, 0x30, 0x07, 0xff, 0xee, 0x53, 0x40, 0x00, 0x40,
    0xff, 0xe4, 0x4a, 0x40, 0x66, 0x0a, 0x00, 0x0f, 0x4e, 0xad, 0x70, 0xff, 0x22, 0xd8, 0x48, 0x6b,
    0x00, 0x22, 0x20, 0x4b, 0x67, 0x0e, 0x4a, 0xae, 0x4e, 0x90, 0xff, 0xe0, 0xff, 0xc0, 0x00, 0x2a,
    0x27, 0x40, 0x67, 0x02, 0x51, 0xc8, 0x02, 0xb6, 0x48, 0x7a, 0x22, 0x78, 0xb0, 0x6e, 0xff, 0xe6,
    0x00, 0x09, 0x32, 0x2e, 0x3e, 0x00, 0x48, 0x41, 0xff, 0xea, 0x43, 0xee, 0x4e, 0x71, 0x74, 0x00,
    0x2f, 0x2c, 0x20, 0x6c, 0x00, 0x3c, 0x00, 0x26, 0x00, 0x50, 0x18, 0x80, 0x30, 0x1f, 0x22, 0x00,
    0x66, 0x0c, 0xff, 0xda, 0x00, 0x38, 0x66, 0x02, 0x30, 0x2c, 0x20, 0x0c, 0x2d, 0x6e, 0x42, 0x40,
    0xff, 0xe2, 0xa9, 0xf0, 0xff, 0x00, 0x37, 0x7c, 0xe5, 0x80, 0xff, 0xdc, 0x48, 0x68, 0x59, 0x4f,
    0x00, 0x34, 0x3e, 0x1f, 0x60, 0x08, 0x2f, 0x06, 0xff, 0xde, 0x60, 0x0a, 0x70, 0x02, 0x00, 0x32,
    0xff, 0xcc, 0x00, 0x80, 0x22, 0x51, 0x10, 0x1f, 0x31, 0x7c, 0xa0, 0x29, 0xff, 0xd8, 0x52, 0x40,
    0x01, 0x00, 0x67, 0x10, 0xa0, 0x23, 0xff, 0xce, 0xff, 0xd4, 0x20, 0x06, 0x48, 0x78, 0x00, 0x2e,
    0x50, 0x4f, 0x43, 0xfa, 0x67, 0x12, 0x76, 0x00, 0x41, 0xe8, 0x4a, 0x6e, 0x20, 0xd9, 0x00, 0x5a,
    0x7f, 0xff, 0x51, 0xca, 0x00, 0x5c, 0x2e, 0x00, 0x02, 0x40, 0x48, 0xc7, 0x67, 0x14, 0x0c, 0x80,
    0x2e, 0x9f, 0xff, 0xd6, 0x80, 0x00, 0x10, 0x00, 0x48, 0x42, 0x4a, 0x6b, 0xff, 0xd2, 0x00, 0x48,
    0x4a, 0x47, 0x4e, 0xd1, 0x20, 0x6f, 0x00, 0x41, 0x60, 0x0c, 0x2a, 0x78, 0x42, 0x2e, 0x32, 0x00,
    0x65, 0x74, 0x67, 0x16, 0x00, 0x44, 0x48, 0x6d, 0x20, 0x08, 0x48, 0x6c, 0x0b, 0x7c, 0x26, 0x40,
    0x04, 0x00, 0x00, 0x68, 0x20, 0x6d, 0x00, 0x0d, 0x2a, 0x40, 0x00, 0x0b, 0x00, 0x3e, 0x02, 0x20,
};

typedef struct { const uint8_t *p; size_t n, i; } cursor;
typedef struct { uint8_t *b; size_t n, cap; bool oom; } obuf;

static bool get(cursor *c, uint8_t *b)
{
    if (c->i >= c->n) return false;
    *b = c->p[c->i++];
    return true;
}

static bool readn(cursor *c, uint8_t *d, size_t n)
{
    if (c->i + n > c->n) return false;
    memcpy(d, c->p + c->i, n);
    c->i += n;
    return true;
}

static size_t remaining(const cursor *c) { return c->i < c->n ? c->n - c->i : 0; }

static bool varint(cursor *c, int32_t *v)
{
    uint8_t head;
    if (!get(c, &head)) return false;
    if (head == 0xff) {
        uint8_t b[4];
        if (!readn(c, b, 4)) return false;
        *v = (int32_t)(((uint32_t)b[0] << 24) | ((uint32_t)b[1] << 16) | ((uint32_t)b[2] << 8) | b[3]);
        return true;
    }
    if (head >= 0x80) {
        uint8_t lo;
        if (!get(c, &lo)) return false;
        *v = (int16_t)(uint16_t)((((head - 0xc0) & 0xff) << 8) | lo);
        return true;
    }
    *v = (int8_t)head;
    return true;
}

static void add(obuf *o, const uint8_t *p, size_t n)
{
    if (o->n + n > o->cap) {
        size_t cap = o->cap ? o->cap * 2 : 4096;
        while (cap < o->n + n) cap *= 2;
        uint8_t *b = (uint8_t *)realloc(o->b, cap);
        if (!b) {
            o->oom = true;
            return;
        }
        o->b = b;
        o->cap = cap;
    }
    memcpy(o->b + o->n, p, n);
    o->n += n;
}

static void add1(obuf *o, uint8_t v) { add(o, &v, 1); }

typedef struct { size_t off, len; } run;

static bool dcmp0(cursor *in, obuf *out, uint32_t expect)
{
    run *prev = NULL;
    size_t nprev = 0, cap = 0;
    bool ok = false;
    for (;;) {
        uint8_t byte;
        if (!get(in, &byte)) goto done;
        if (byte < 0x20) {
            uint8_t count_div2 = byte & 0x0f;
            if ((byte == 0x00 || byte == 0x10) && !get(in, &count_div2)) goto done;
            const size_t n = (size_t)count_div2 * 2;
            if (remaining(in) < n) goto done;
            const size_t at = out->n;
            add(out, in->p + in->i, n);
            in->i += n;
            if (byte >= 0x10) {
                if (nprev == cap) {
                    cap = cap ? cap * 2 : 64;
                    run *r = (run *)realloc(prev, cap * sizeof *r);
                    if (!r) goto done;
                    prev = r;
                }
                prev[nprev].off = at;
                prev[nprev++].len = n;
            }
        } else if (byte == 0x20 || byte == 0x21 || byte == 0x22 || (byte >= 0x23 && byte <= 0x4a)) {
            size_t idx;
            if (byte <= 0x21) {
                uint8_t next;
                if (!get(in, &next)) goto done;
                idx = 0x28 + (((size_t)(byte - 0x20) << 8) | next);
            } else if (byte == 0x22) {
                uint8_t b[2];
                if (!readn(in, b, 2)) goto done;
                idx = 0x28 + (((size_t)b[0] << 8) | b[1]);
            } else {
                idx = (size_t)(byte - 0x23);
            }
            if (idx >= nprev) goto done;
            const run r = prev[idx];
            uint8_t tmp[512];
            for (size_t k = 0; k < r.len; k += sizeof tmp) {          // (out may move as it grows)
                const size_t m = r.len - k < sizeof tmp ? r.len - k : sizeof tmp;
                memcpy(tmp, out->b + r.off + k, m);
                add(out, tmp, m);
            }
        } else if (byte >= 0x4b && byte <= 0xfd) {
            add(out, kDcmp0Table + (size_t)(byte - 0x4b) * 2, 2);
        } else if (byte == 0xfe) {
            uint8_t kind;
            if (!get(in, &kind)) goto done;
            if (kind == 0x00) {
                int32_t seg, count, cur;
                if (!varint(in, &seg) || !varint(in, &count) || !varint(in, &cur) || count <= 0) goto done;
                const uint8_t tail[6] = {0x3f, 0x3c, (uint8_t)(seg >> 8), (uint8_t)seg, 0xa9, 0xf0};
                add(out, tail, 6);
                uint8_t entry[8] = {(uint8_t)(cur >> 8), (uint8_t)cur, 0x3f, 0x3c, (uint8_t)(seg >> 8), (uint8_t)seg, 0xa9, 0xf0};
                add(out, entry, 8);
                for (int32_t n = 1; n < count; n++) {
                    int32_t diff;
                    if (!varint(in, &diff)) goto done;
                    cur = (cur + (diff - 6)) & 0xffff;
                    entry[0] = (uint8_t)(cur >> 8);
                    entry[1] = (uint8_t)cur;
                    add(out, entry, 8);
                }
            } else if (kind == 0x02 || kind == 0x03) {
                const int n = kind == 0x02 ? 1 : 2;
                int32_t val, count;
                if (!varint(in, &val) || !varint(in, &count)) goto done;
                count += 1;
                if (count <= 0) goto done;
                const uint8_t bytes[2] = {(uint8_t)(n == 2 ? (val >> 8) : val), (uint8_t)val};
                for (int32_t i = 0; i < count; i++) add(out, n == 2 ? bytes : bytes + 1, (size_t)n);
            } else if (kind == 0x04) {
                int32_t initial, count;
                if (!varint(in, &initial) || !varint(in, &count) || count < 0) goto done;
                add1(out, (uint8_t)(initial >> 8));
                add1(out, (uint8_t)initial);
                uint32_t cur = (uint32_t)initial & 0xffffu;
                for (int32_t i = 0; i < count; i++) {
                    uint8_t d;
                    if (!get(in, &d)) goto done;
                    cur = (cur + (uint32_t)(int8_t)d) & 0xffffu;
                    add1(out, (uint8_t)(cur >> 8));
                    add1(out, (uint8_t)cur);
                }
            } else if (kind == 0x06) {
                int32_t initial, count;
                if (!varint(in, &initial) || !varint(in, &count)) goto done;
                uint32_t cur = (uint32_t)initial;
                const uint8_t b0[4] = {(uint8_t)(cur >> 24), (uint8_t)(cur >> 16), (uint8_t)(cur >> 8), (uint8_t)cur};
                add(out, b0, 4);
                for (int32_t i = 0; i < count; i++) {
                    int32_t diff;
                    if (!varint(in, &diff)) goto done;
                    cur += (uint32_t)diff;
                    const uint8_t b[4] = {(uint8_t)(cur >> 24), (uint8_t)(cur >> 16), (uint8_t)(cur >> 8), (uint8_t)cur};
                    add(out, b, 4);
                }
            } else {
                goto done;
            }
        } else if (byte == 0xff) {
            break;
        } else {
            goto done;
        }
        if (out->oom) goto done;
    }
    if ((expect & 1u) && out->n == (size_t)expect + 1) out->n--;
    ok = true;
done:
    free(prev);
    return ok;
}

static bool dcmp2(cursor *in, obuf *out, uint32_t expect, uint8_t table_count_m1, uint8_t flags)
{
    const uint8_t *table = kDcmp2Table;
    uint8_t custom[512];
    if (flags & 1u) {
        const size_t n = (size_t)table_count_m1 + 1u;
        if (!readn(in, custom, n * 2)) return false;
        table = custom;
    } else if (table_count_m1 != 0) {
        return false;
    }
    const size_t table_n = (flags & 1u) ? (size_t)table_count_m1 + 1u : 256u;
#define EMIT(idx) do { if ((idx) >= table_n) return false; add(out, table + (size_t)(idx) * 2, 2); } while (0)
    if (!(flags & 2u)) {
        for (;;) {
            if (out->n >= expect) break;
            uint8_t b;
            if (!get(in, &b)) break;
            if (out->n + 1 == expect && (expect & 1u) && remaining(in) == 0) {
                add1(out, b);
                break;
            }
            EMIT(b);
        }
    } else {
        for (;;) {
            if (out->n >= expect) break;
            uint8_t tag;
            if (!get(in, &tag)) break;
            if (out->n + 1 == expect && (expect & 1u) && remaining(in) == 0) {
                add1(out, tag);
                break;
            }
            for (int bit = 7; bit >= 0; bit--) {
                if (out->n >= expect) break;
                if (tag & (1u << bit)) {
                    uint8_t idx;
                    if (!get(in, &idx)) return out->n >= expect;
                    EMIT(idx);
                } else {
                    uint8_t lit[2];
                    const size_t want = expect - out->n < 2 ? expect - out->n : 2;
                    if (!readn(in, lit, want)) {
                        if (want == 2 && remaining(in) == 1 && (expect & 1u) && out->n + 1 == expect) {
                            uint8_t last;
                            if (!get(in, &last)) return false;
                            add1(out, last);
                            return true;
                        }
                        return out->n >= expect;
                    }
                    add(out, lit, want);
                }
            }
        }
    }
#undef EMIT
    return !out->oom;
}

uint8_t *mac_decompress_resource(const uint8_t *data, size_t size, size_t *out_len)
{
    if (!data || size < 18) return NULL;
    if (data[0] != 0xa8 || data[1] != 0x9f || data[2] != 0x65 || data[3] != 0x72) return NULL;
    const uint16_t hdr_len = (uint16_t)((data[4] << 8) | data[5]);
    const uint8_t header_type = data[6];
    const uint32_t expect = ((uint32_t)data[8] << 24) | ((uint32_t)data[9] << 16) | ((uint32_t)data[10] << 8) | data[11];
    if (hdr_len != 0x12 || expect < 2 || expect > 0x100000) return NULL;
    cursor in = {data + 18, size - 18, 0};
    obuf out = {NULL, 0, 0, false};
    bool ok = false;
    if (header_type == 8) {
        const int16_t id = (int16_t)((data[14] << 8) | data[15]);
        ok = id == 0 && dcmp0(&in, &out, expect);
    } else if (header_type == 9) {
        const int16_t id = (int16_t)((data[12] << 8) | data[13]);
        ok = id == 2 && dcmp2(&in, &out, expect, data[16], data[17]);
    }
    if (ok && out.n > expect) out.n = expect;
    if (!ok || out.oom || (out.n != expect && !((expect & 1u) && out.n + 1 == expect))) {
        free(out.b);
        return NULL;
    }
    *out_len = out.n;
    return out.b;
}
