// adb_hid.h - a USB keyboard (HID usages) as Apple's keyboards (the Mac's
// key codes, ADB's): the board frontends of the IIGS and the Macintoshes.
// The arrows and Control differ by machine: the caller gives them. Included
// once (static).
#pragma once
#include <stdint.h>

#define ADB_NONE 0xff

// HID usage 0x00-0x67 -> Apple key code (ADB_NONE: none)
static const uint8_t adb_hid_main[0x68] = {
    [0x00 ... 0x67] = ADB_NONE,
    [0x04] = 0x00, [0x05] = 0x0b, [0x06] = 0x08, [0x07] = 0x02, [0x08] = 0x0e, [0x09] = 0x03, [0x0a] = 0x05,
    [0x0b] = 0x04, [0x0c] = 0x22, [0x0d] = 0x26, [0x0e] = 0x28, [0x0f] = 0x25, [0x10] = 0x2e, [0x11] = 0x2d,
    [0x12] = 0x1f, [0x13] = 0x23, [0x14] = 0x0c, [0x15] = 0x0f, [0x16] = 0x01, [0x17] = 0x11, [0x18] = 0x20,
    [0x19] = 0x09, [0x1a] = 0x0d, [0x1b] = 0x07, [0x1c] = 0x10, [0x1d] = 0x06,
    [0x1e] = 0x12, [0x1f] = 0x13, [0x20] = 0x14, [0x21] = 0x15, [0x22] = 0x17, [0x23] = 0x16, [0x24] = 0x1a,
    [0x25] = 0x1c, [0x26] = 0x19, [0x27] = 0x1d,
    [0x28] = 0x24, [0x29] = 0x35, [0x2a] = 0x33, [0x2b] = 0x30, [0x2c] = 0x31, [0x2d] = 0x1b, [0x2e] = 0x18,
    [0x2f] = 0x21, [0x30] = 0x1e, [0x31] = 0x2a, [0x32] = 0x2a, [0x33] = 0x29, [0x34] = 0x27, [0x35] = 0x32,
    [0x36] = 0x2b, [0x37] = 0x2f, [0x38] = 0x2c, [0x39] = 0x39,
    [0x53] = 0x47, [0x54] = 0x4b, [0x55] = 0x43, [0x56] = 0x4e, [0x57] = 0x45, [0x58] = 0x4c,
    [0x59] = 0x53, [0x5a] = 0x54, [0x5b] = 0x55, [0x5c] = 0x56, [0x5d] = 0x57, [0x5e] = 0x58, [0x5f] = 0x59,
    [0x60] = 0x5b, [0x61] = 0x5c, [0x62] = 0x52, [0x63] = 0x41, [0x67] = 0x51,
};

typedef struct {
    uint8_t left, right, down, up;      // the arrows
    uint8_t ctrl;                       // Control (ADB_NONE: Command)
    uint8_t shift, option, command;
} adb_hid_keys;

static const adb_hid_keys adb_hid_adb = { 0x3b, 0x3c, 0x3d, 0x3e, 0x36, 0x38, 0x3a, 0x37 };

// Marks in held[128] the Apple keys of the USB keyboard's keys held
static void adb_hid_held(const adb_hid_keys *k, bool (*key)(int usage), bool held[128])
{
    for (int u = 0; u < 0x68; u++)
        if (adb_hid_main[u] != ADB_NONE && key(u)) held[adb_hid_main[u]] = true;
    if (key(0x50)) held[k->left] = true;
    if (key(0x4f)) held[k->right] = true;
    if (key(0x51)) held[k->down] = true;
    if (key(0x52)) held[k->up] = true;
    if (key(0xe0) || key(0xe4)) held[k->ctrl != ADB_NONE ? k->ctrl : k->command] = true;
    if (key(0xe1) || key(0xe5)) held[k->shift] = true;
    if (key(0xe2) || key(0xe6)) held[k->option] = true;
    if (key(0xe3) || key(0xe7)) held[k->command] = true;
}
